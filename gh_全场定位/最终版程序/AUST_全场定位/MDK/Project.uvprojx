# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Source\APP;..\Source\BSP;..\Source\STM32F10xLib\inc;..\Source\STM32F10xLib\M3;..\Source\Public;..\Source\USB\lib;..\Source\USB\src;..\Source\Drive;..\..\..\..\STM32正交编码器\STM32正交编码器\EXTI;..\..\..\..\STM32正交编码器\STM32正交编码器\HARDWARE;..\..\..\..\STM32正交编码器\STM32正交编码器\Libraries\FWlib\inc;..\..\..\..\STM32正交编码器\STM32正交编码器\Libraries\FWlib\src;..\..\..\..\STM32正交编码器\STM32正交编码器\SYSTEM\delay;..\..\..\..\STM32正交编码器\STM32正交编码器\SYSTEM\sys;..\..\..\..\STM32正交编码器\STM32正交编码器\SYSTEM\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../Source/APP/: Main.c encode.c encode.h
  group DRIVER
    ../Source/Drive/: delay.c IOI2C.c UART1.c UART2.c DIO.c
  group Public
    ../Source/Public/: Queue.c
  group FWLib
    ../Source/STM32F10xLib/M3/: system_stm32f10x.c stm32f10x_it.c
    ../Source/STM32F10xLib/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c
    ../Source/STM32F10xLib/startup/: startup_stm32f10x_hd.s
  group USB
    ../Source/USB/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
  group USB/Lib
    ../Source/USB/lib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group DOC
    ../DOC/: Note.h
  group HARDWARE
    ../../../../STM32正交编码器/STM32正交编码器/HARDWARE/: encode.c encode.h lcd.c lcd.h
software components: CMSIS:CORE 4.3.0
